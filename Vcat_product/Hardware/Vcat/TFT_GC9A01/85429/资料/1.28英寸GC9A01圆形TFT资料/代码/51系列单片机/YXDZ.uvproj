# Keil uVision project YXDZ.uvproj, settings and files
target YXDZ (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: YXDZ +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd_init.c lcd.c
  group Readme
    ./Readme/: readme.txt
